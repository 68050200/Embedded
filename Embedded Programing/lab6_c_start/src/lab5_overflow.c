/* ============================================================
   LAB 5 : Overflow -- บั๊กยอดฮิตของงานฝังตัว
   วิธีรัน: เลือก env:lab5_overflow ที่แถบล่าง -> กด Upload

   ครั้งที่ 3 เราจำลอง overflow ใน Python ด้วย  (u + 1) & 0xFF
   ใน C ไม่ต้องทำอะไรเลย มันเกิดขึ้นเอง
   ============================================================ */

#include <stdio.h>
#include <stdint.h>

int main(void) {

    /* ------------------------------------------------------------
       [1] ตัวอย่าง
       ------------------------------------------------------------ */
    printf("--- [1] ตัวอย่าง ---\n");

    /* uint8_t เก็บได้ 0 ถึง 255 เมื่อเกิน 255 จะวนกลับไป 0 */
    uint8_t u = 250;
    printf("uint8_t เริ่มที่ 250: ");
    for (int i = 0; i < 8; i++) {
        printf("%u ", u);
        u++;
    }
    printf("\n   ^ สังเกต: หลัง 255 กลายเป็น 0\n");

    /* int8_t เก็บได้ -128 ถึง 127 เมื่อเกิน 127 จะกระโดดไป -128 */
    int8_t s = 124;
    printf("\nint8_t เริ่มที่ 124: ");
    for (int i = 0; i < 6; i++) {
        printf("%d ", s);
        s++;
    }
    printf("\n   ^ สังเกต: หลัง 127 กลายเป็น -128\n");

    printf("\nไม่มี error ไม่มี warning โปรแกรมเดินต่อเงียบ ๆ\n");


    /* ------------------------------------------------------------
       [2] ลองทำเอง
       ------------------------------------------------------------ */
    printf("\n--- [2] ลองทำเอง ---\n");

    /* TODO 5.1 : เขียน loop แบบเดียวกัน แต่ใช้ uint16_t เริ่มที่ 65530
                  วนซ้ำ 8 ครั้ง ดูว่า overflow ที่ค่าใด               */
    uint16_t u1 = 65530;
    printf("TODO 5.1 : uint16_t เริ่มที่ 65530: ");
    for (int i = 0; i < 8; i++) {
        printf("%u\n ", u1);
        u1++;
    }
    /* TODO 5.2 : ประกาศ uint8_t counter = 0; แล้ววน 300 รอบ
                  โดยแต่ละรอบ counter++ จากนั้น printf ค่าสุดท้าย
                  ทายก่อนว่าจะได้เท่าไร แล้วค่อยรันเทียบ              */
    uint8_t counter = 0;
    for (int i = 0; i < 300; i++) { /* uint8_t เก็บ 0 ถึง 255 เพราะค่าจึง overflow ทำให้ค่าเป็น 300 % 256 = 44 */ 
      counter++;
    }

    printf("TODO 5.2 : ค่าสุดท้าย %u\n", counter);
    /* TODO 5.3 : underflow -- ประกาศ uint8_t z = 0; แล้ว z--;
                  printf ดูว่าได้ค่าอะไร                             */
     uint8_t z = 0;
     z--;
     printf("TODO 5.3 : z - 1 = %u\n",z);


    /* ------------------------------------------------------------
       [3] ท้าทาย
       ------------------------------------------------------------ */
    printf("\n--- [3] ท้าทาย ---\n");

    /* TODO 5.4 : เซนเซอร์ส่งค่ามาทุก 1 วินาที เก็บผลรวมใน uint16_t 	0 ถึง 65,535
                  ถ้าค่าที่ส่งมาแต่ละครั้งคือ 100 จะใช้เวลากี่วินาที
                  ก่อนตัวแปรจะ overflow  เขียนโปรแกรมหาคำตอบ         */
    uint16_t sum = 0;
    uint16_t value = 100;
    int timer = 0;
    
    while(1) {
      timer++;
      uint16_t prevsum = sum;
      sum = sum+value;
      if (prevsum > sum ) {
         printf("overflow ที่วินาทีที่ %d\n", timer);
         break;
      }
    }

    return 0;
}
