/* ============================================================
   LAB 2 : เงื่อนไขและการวนซ้ำ
   วิธีรัน: เลือก env:lab2_control ที่แถบล่าง -> กด Upload
   ============================================================ */

#include <stdio.h>

int main(void) {

    /* ------------------------------------------------------------
       [1] ตัวอย่าง
       ------------------------------------------------------------
       Python : if n % 2 == 0:        C : if (n % 2 == 0) {
                    print("even")             printf("even\n");
                else:                     } else {
                    print("odd")              printf("odd\n");
                                          }
    */
    printf("--- [1] ตัวอย่าง ---\n");

    int n = 7;
    if (n % 2 == 0) {
        printf("%d เป็นเลขคู่\n", n);
    } else {
        printf("%d เป็นเลขคี่\n", n);
    }

    /* for ของ C มี 3 ส่วน:  ( เริ่มต้น ; เงื่อนไขทำต่อ ; เปลี่ยนค่าทุกรอบ ) */
    int total = 0;
    for (int i = 1; i <= 10; i++) {
        total += i;
    }
    printf("ผลรวม 1 ถึง 10 = %d\n", total);

    /* while เหมือน Python แค่เพิ่มวงเล็บและปีกกา */
    int count = 3;
    while (count > 0) {
        printf("นับถอยหลัง %d\n", count);
        count--;              /* count-- คือ count = count - 1 */
    }


    /* ------------------------------------------------------------
       [2] ลองทำเอง
       ------------------------------------------------------------ */
    printf("\n--- [2] ลองทำเอง ---\n");

    /* TODO 2.1 : เขียน for loop พิมพ์เลขคู่ตั้งแต่ 2 ถึง 20
                  ผลที่ต้องได้: 2 4 6 8 10 12 14 16 18 20         */
     for (int i = 2; i <= 20; i++) {
         printf("%d\n", i);
     }

    /* TODO 2.2 : เขียน for loop นับถอยหลังจาก 10 ลงมาถึง 1
                  คำใบ้: ใช้ i-- แทน i++                          */
     printf("TODO 2.2\n");
     for (int i = 10; i >= 1; i--) {
         printf("%d\n", i);
     }
    /* TODO 2.3 : เขียนโปรแกรมหาผลรวมของเลขคี่ตั้งแต่ 1 ถึง 99
                  แล้ว printf ผลลัพธ์                              */
     int total2 = 0;
     for (int i = 1; i <= 99; i++) {
        if (i % 2 != 0) {
            total2 += i;
        }
     }
     printf("TODO 2.3 = %d\n", total2);

    /* ------------------------------------------------------------
       [3] ท้าทาย
       ------------------------------------------------------------ */
    printf("\n--- [3] ท้าทาย ---\n");

    /* TODO 2.4 : เขียน for loop ซ้อนกัน 2 ชั้น พิมพ์สูตรคูณแม่ 2 ถึงแม่ 5
                  รูปแบบ:  2 x 1 = 2
                           2 x 2 = 4  ...                          */
     for (int i = 1; i <= 5; i++) {
        for (int j = 1; j <= 12; j++) {
            printf(" %d x %d = %d\n", i, j, i*j);
        }
     }

    return 0;
}
