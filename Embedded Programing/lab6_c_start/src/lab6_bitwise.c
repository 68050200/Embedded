/* ============================================================
   LAB 6 : Bitwise -- เตรียมคุมฮาร์ดแวร์ครั้งหน้า
   วิธีรัน: เลือก env:lab6_bitwise ที่แถบล่าง -> กด Upload
   ============================================================ */

#include <stdio.h>
#include <stdint.h>

/* ฟังก์ชันช่วยพิมพ์เลขฐานสอง 8 บิต (ให้มาแล้ว ใช้ได้เลย) */
void print_binary(uint8_t v) {
    for (int i = 7; i >= 0; i--) {
        printf("%d", (v >> i) & 1);
    }
}

int count_ones(uint32_t n){
    int count = 0;
    while (n != 0) {
        count += (n & 1);   // เช็คบิตขวาสุดว่าเป็น 1 ไหม แล้วบวกเข้า count
        n >>= 1;             // เลื่อนบิตทั้งหมดไปทางขวา 1 ตำแหน่ง
    }
    return count;
}


int main(void) {

    /* ------------------------------------------------------------
       [1] ตัวอย่าง: ตัวดำเนินการพื้นฐาน
       ------------------------------------------------------------ */
    printf("--- [1] ตัวอย่าง ---\n");

    printf("0b1100 & 0b1010 = %2d   (AND: เป็น 1 ทั้งคู่ -> 1)\n", 0b1100 & 0b1010);
    printf("0b1100 | 0b1010 = %2d   (OR : มีตัวใดเป็น 1 -> 1)\n", 0b1100 | 0b1010);
    printf("0b1100 ^ 0b1010 = %2d   (XOR: ต่างกัน -> 1)\n", 0b1100 ^ 0b1010);
    printf("1 << 3          = %2d   (เลื่อนซ้าย 3 = คูณ 2 สามครั้ง)\n", 1 << 3);
    printf("13 >> 1         = %2d   (เลื่อนขวา 1 = หาร 2)\n", 13 >> 1);

    /* 4 เทคนิคคุมบิต -- จำให้ขึ้นใจ ครั้งหน้าใช้คุมขาของชิป */
    printf("\n--- 4 เทคนิคคุมบิต ---\n");
    uint8_t reg = 0b00000000;

    printf("เริ่มต้น        reg = "); print_binary(reg); printf("  (%u)\n", reg);

    reg |= (1 << 2);          /* SET บิต 2 เป็น 1 */
    printf("SET บิต 2      reg = "); print_binary(reg); printf("  (%u)\n", reg);

    reg |= (1 << 5);          /* SET บิต 5 โดยไม่กระทบบิต 2 */
    printf("SET บิต 5      reg = "); print_binary(reg); printf("  (%u)\n", reg);

    reg &= ~(1 << 2);         /* CLEAR บิต 2 กลับเป็น 0 */
    printf("CLEAR บิต 2    reg = "); print_binary(reg); printf("  (%u)\n", reg);

    reg ^= (1 << 0);          /* TOGGLE บิต 0 สลับค่า */
    printf("TOGGLE บิต 0   reg = "); print_binary(reg); printf("  (%u)\n", reg);

    if (reg & (1 << 5)) {     /* CHECK ว่าบิต 5 เป็น 1 ไหม */
        printf("CHECK: บิต 5 เป็น 1 อยู่\n");
    }


    /* ------------------------------------------------------------
       [2] ลองทำเอง
       ------------------------------------------------------------ */
    printf("\n--- [2] ลองทำเอง ---\n");

    uint8_t my_reg = 0b00000000;
    printf("my_reg เริ่มต้น = "); print_binary(my_reg); printf("\n");

    /* TODO 6.1 : SET บิตที่ 3 แล้วพิมพ์ด้วย print_binary()          */
    my_reg |= (1 << 3);    
    printf("SET บิต 3      myreg = "); print_binary(my_reg); printf("  (%u)\n", my_reg);

    /* TODO 6.2 : SET บิตที่ 0 และบิตที่ 7 พร้อมกันในคำสั่งเดียว
                  คำใบ้: (1 << 0) | (1 << 7)                        */
    my_reg |= (1 << 0) | (1 << 7);      
    printf("SET บิตที่ 0 และบิตที่ 7 พร้อมกัน     myreg = "); print_binary(my_reg); printf("  (%u)\n", my_reg);

    /* TODO 6.3 : CLEAR บิตที่ 7 แล้วพิมพ์ผล                        */
    my_reg &= ~(1 << 7);     
    printf("CLEAR บิต 7    myreg = "); print_binary(my_reg); printf("  (%u)\n", my_reg);

    /* TODO 6.4 : เขียน if ตรวจว่าบิตที่ 3 เป็น 1 หรือไม่
                  ถ้าใช่ให้พิมพ์ว่า "บิต 3 ติดอยู่"                  */
    if (my_reg & (1 << 3)) {
        printf("บิต 3 ติดอยู่\n");
    }


    /* ------------------------------------------------------------
       [3] ท้าทาย
       ------------------------------------------------------------ */
    printf("\n--- [3] ท้าทาย ---\n");

    /* TODO 6.5 : เขียนฟังก์ชัน int count_ones(uint32_t n)
                  คืนจำนวนบิตที่เป็น 1
                  (โจทย์เดียวกับ Quiz วัดระดับครั้งที่ 1 ที่เคยเขียน
                   ด้วย Python -- คราวนี้เขียนด้วย C)
                  ประกาศฟังก์ชันไว้เหนือ main() แล้วทดสอบกับ 13 และ 255 */
    printf("count_ones(13)  = %d\n", count_ones(13));
    printf("count_ones(255) = %d\n", count_ones(255));

    return 0;
}
